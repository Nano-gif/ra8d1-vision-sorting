# Keil uVision project Robotic_Arm_Control.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Robotic_Arm_Control +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  c include: .\APP;.\Components;.\src;.\Components\ringbuffer
  asm misc: --via=./via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c bsp_systick.c bsp_systick.h
  group APP
    ./APP/: scheduler.c debug_uart_app.c hmi_uart_app.c rs485_uart_app.c modbus_slave_app.c uart_printf.c pca9685_app.c arm_control_app.c arm_config_app.c arm_kinematics_app.c arm_action_app.c arm_manual_app.c buzzer_app.c
  group Components
    ./Components/ringbuffer/: ringbuffer.c
software components: Flex Software:RA Configuration 1.0.0
